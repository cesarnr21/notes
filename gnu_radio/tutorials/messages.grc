options:
  parameters:
    generate_options: qt_gui
    id: messages
    output_language: python
    title: messages_tutorial
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='multiplexer',   # will show up in GRC\n            in_sig=[np.complex64, np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.select_port_name = 'select_port'\n        self.message_port_register_in(pmt.intern(self.select_port_name))\n        self.set_msg_handler(pmt.intern(self.select_port_name), self.handle_msg)\n        self.selector = True\n\n    def handle_msg(self, msg):\n        self.selector = pmt.to_bool(msg)\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        if (self.selector):\n            output_items[0][:] = input_items[0]\n        else:\n            output_items[0][:] = input_items[1]\n\n\n        return len(output_items[0])\n\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, num_samples_count = 128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='selector_control',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.num_samples_count = num_samples_count
              self.port_name = 'message_output'
              self.message_port_register_out(pmt.intern(self.port_name))
              self.state = True
              self.counter = 0

          def handle_msg(self, msg):
              self.selector = pmt.to_bool(msg)

          def work(self, input_items, output_items):
              """example: multiply with constant"""

              self.counter = self.counter + len(output_items[0])

              if (self.counter > self.num_samples_count):
                  pmt_msg = pmt.from_bool(self.state)
                  self.message_port_pub(pmt.intern(self.port_name), pmt_msg)
                  self.counter = 0

              output_items[0][:] = input_items[0]
              return len(output_items[0])
    num_samples_count: '32000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}

connections:
- [analog_noise_source_x_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0, '0', epy_block_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_1, '0', blocks_throttle_0, '0']
- [epy_block_1, message_output, blocks_message_debug_0, print]
- [epy_block_1, message_output, virtual_sink_0, '0']
- [virtual_source_0, '0', epy_block_0, select_port]

metadata:
  file_format: 1
